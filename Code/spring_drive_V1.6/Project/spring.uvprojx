# Keil uVision project spring.uvprojx, settings and files
target spring (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM181xC Synwit
  pack: Synwit.SWM32_DFP.1.20.3
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x3E000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: driver +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --diag_suppress=1296
  c include: ..\Application\Drivers\Include;..\Application\Drivers;..\Application;..\Application\SEEGER;..\Application\MALLOC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3e000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../Application/: main.c vm.c swm_it.c ambient.c
    ../Application/Drivers/Source/: tick.c
  group Drivers
    ../Application/Drivers/Source/: motor_driver.c uart.c rs485.c led.c timer.c infrared_ray_check.c lock.c address.c
  group Doc
    ../Doc/: doc.txt
  group Seeger
    ../Application/SEEGER/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group SRAM_Manager
    ../Application/MALLOC/: malloc.c
software components: CMSIS:CORE 5.5.0, Device:Driver:Cache 1.6.0, Device:Driver:DMA 1.6.0, Device:Driver:EXIT 1.6.0, Device:Driver:Flash 1.6.0, Device:Driver:GPIO 1.6.0, Device:Driver:IRQMux 1.6.0, Device:Driver:Port 1.6.0, Device:Driver:Sleep 1.6.0, Device:Driver:Timer 1.6.0, Device:Driver:UART 1.6.0, Device:Driver:WDT 1.6.0, Device:Startup 1.6.0
